
#
# WepSIM (https://wepsim.github.io/wepsim/)
#

.data
    msg:   .byte 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0,
                 0,1,0,1,0,1,1,1, 0,1,1,1,0,1,1,1, 0,1,0,1,0,0,0,0,
                 0,1,0,1,0,1,0,1, 0,1,0,1,0,1,0,1, 0,1,0,1,0,0,0,0,
                 0,1,1,1,0,1,1,1, 0,1,1,1,0,1,1,1, 0,1,1,1,0,0,0,0,
                 0,1,0,1,0,1,0,1, 0,1,0,0,0,1,0,0, 0,0,0,1,0,0,0,0,
                 0,1,0,1,0,1,0,1, 0,1,0,0,0,1,0,0, 0,1,1,1,0,0,0,0,
                 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0,
                 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0,

                 0,1,0,1,0,1,1,1, 0,1,1,1,0,1,1,1, 0,0,0,0,0,0,0,0,
                 0,1,0,1,0,1,0,0, 0,1,0,1,0,1,0,1, 0,0,0,0,0,0,0,0,
                 0,1,1,1,0,1,1,1, 0,1,1,1,0,1,0,1, 0,0,0,0,0,0,0,0,
                 0,0,0,1,0,1,0,0, 0,1,0,1,0,1,1,0, 0,0,0,0,0,0,0,0,
                 0,1,1,1,0,1,1,1, 0,1,0,1,0,1,0,1, 0,0,0,0,0,0,0,0,
                 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0,
                 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0,

                 0,1,1,1,0,1,1,1, 0,1,1,1,0,1,1,1, 0,0,1,0,0,0,0,0,
                 0,0,0,1,0,1,0,1, 0,0,0,1,0,0,0,1, 0,0,1,0,0,0,0,0,
                 0,1,1,1,0,1,0,1, 0,1,1,1,0,1,1,1, 0,0,1,0,0,0,0,0,
                 0,1,0,0,0,1,0,1, 0,1,0,0,0,0,0,1, 0,0,0,0,0,0,0,0,
                 0,1,1,1,0,1,1,1, 0,1,1,1,0,1,1,1, 0,0,1,0,0,0,0,0,
                 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0,
                 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0,
                 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0,
                 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0, 0,0,0,0,0,0,0,0

.text


   main:   # initial address
           la   $t5 msg

           # for (i=22; i!=0; i--)
           li   $t0 22
    loop3: beq  $t0 $0 end3

           # out address to data
           out  $t5 0x3108

           # out 'DMA'   to control
           li   $t6 0x20
           out  $t6 0x3104

           # next
           addi  $t5 $t5 24
           addi  $t0 $t0 -1
           b loop3
     end3:
           # the end
           jr $ra


    # a) Using Programmed I/O
   main_a: la  $t8 msg
           # for (y=0; y<24; y++)
           li  $t7 1
           li  $t0 24
           li  $t1 0
   loop_y: beq $t1 $t0 end_y
           # for (x=0; x<24; x++)
           li  $t2 0
   loop_x: beq $t2 $t0 end_x
           lb   $t6 ($t8)
           addi $t8 $t8 1
           # m = <x|y|0|v>
           li   $t5 0
           or   $t5 $t5 $t2
           sll  $t5 $t5 8
           or   $t5 $t5 $t1
           sll  $t5 $t5 8
           or   $t5 $t5 $0
           sll  $t5 $t5 8
           or   $t5 $t5 $t6
           # out <x|y|0|v> to data
           out  $t5 0x3108
           # out set pixel to control
           li   $t5 0x10
           out  $t5 0x3104
           # for (x...
           add  $t2 $t2 $t7
           b loop_x
    end_x: # for (y...
           add  $t1 $t1 $t7
           b loop_y
    end_y:
           # the end
           jr $ra


    # b) Using DMA
   main_b: # out 'initial address' to the data register
           la   $t5 msg
           out  $t5 0x3108
           # out 'use DMA' to the control register
           li   $t5 0x20
           out  $t5 0x3104
           # the end
           jr $ra

